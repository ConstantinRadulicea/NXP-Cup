# Repository ConstantinRadulicea/NXP-Cup

## KiCad design PCB-Kicad/Modul_Main_Board/Modul_Main_Board.kicad_pcb

Parts:
C1, C2: CP_Radial_D10.0mm_P5.00mm
D1: LED; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
IC1: TEENSY_4.0; TEENSY40_1; Manufacturer_Part_Number TEENSY 4.0
J1: Pixy Cam1; IDC-Header_2x04_P2.54mm_Vertical
J2: Pixy Cam2; IDC-Header_2x04_P2.54mm_Vertical
J4, J5, J6: HC-SR04; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J7: Servo; PinHeader_1x03_P2.54mm_Vertical
J8: ESC; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J9: ESP8266; PinSocket_1x04_P2.54mm_Vertical
J10: LcdModule; IDC-Header_2x04_P2.54mm_Vertical
J12: Screw Conn1; KF3012P; Manufacturer_Part_Number KF301-2P
J13: On/Off Switch; PinHeader_1x03_P2.54mm_Vertical
J14: XT60-M; AMASS_XT60-M; PARTREV V1.2
J15, J16: Exposed Pins; PinHeader_1x14_P2.54mm_Vertical
R1, R2, R3, R4, R5, R7, R8, R9: 1k; R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal
R6: 1K; R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal
R10: 100; R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal
U1: XL6009

Connections:
+5V: C2.1, IC1.33 (VIN_(3.6_TO_5.5_VOLTS)), J1.2, J2.2, J4.1, J5.1, J6.1, J7.2, J8.2, J9.2, J10.7, J16.14, U1.3 (OUT+)
+BAT: C1.1, J12.1, J13.1, J13.3, J14.P (POS), U1.1 (IN+)
-BAT: C1.2, J12.2, J14.N (NEG), U1.2 (IN-)
DECREMENT: IC1.23 (16), J10.4, J16.4
ECHO1: IC1.4 (2), J4.3, J15.4, R2.1, R3.1, R3.2
ECHO2: IC1.6 (4), J5.3, J15.6, R5.1, R6.1, R6.2
ECHO3: IC1.8 (6), J6.3, J15.8, R8.1, R9.1, R9.2
GND: C2.2, D1.1 (K), IC1.1 (GND_1), IC1.32 (GND_3), J1.6, J2.6, J4.4, J5.4, J6.4, J7.1, J8.1, J9.1, J10.8, J15.1, J16.13, R1.2, R4.2, R7.2, U1.4 (OUT-)
INCREMENT: IC1.24 (17), J10.3, J16.5
LED: IC1.28 (21), J16.9, R10.1
LEFT: IC1.22 (15), J10.1, J16.3
unnamed: D1.2 (A), R10.2
unnamed: IC1.31 (3.3V(250_MA_MAX)), J16.12
unnamed: IC1.12 (10), J15.12
unnamed: IC1.27 (20), J16.8
unnamed: R1.1, R2.2
unnamed: R4.1, R5.2
unnamed: R7.1, R8.2
RIGHT: IC1.21 (14), J10.2, J16.2
RX: IC1.2 (0), J9.3, J15.2
SCL: IC1.26 (19), J10.5, J16.7
SDA: IC1.25 (18), J10.6, J16.6
SIG_ESC: IC1.30 (23), J8.3, J16.11
SIG_SERVO: IC1.29 (22), J7.3, J16.10
SPI_MISO: IC1.14 (12), J1.1, J2.1, J15.14
SPI_MOSI: IC1.13 (11), J1.4, J2.4, J15.13
SPI_SCK: IC1.20 (13), J1.3, J2.3, J16.1
SPI_SS1: IC1.10 (8), J1.7, J15.10
SPI_SS2: IC1.11 (9), J2.7, J15.11
TRIG1: IC1.5 (3), J4.2, J15.5
TRIG2: IC1.7 (5), J5.2, J15.7
TRIG3: IC1.9 (7), J6.2, J15.9
TX: IC1.3 (1), J9.4, J15.3

Notes on the sheet:
+5V
GND
Voltage Conversion
Voltage Dividers +5V -> +3.3V
GND
+5V
Motors
Distance Sensors
Displayed Information
Cameras

Board: 2 copper layers, 80.0 x 100.0 mm, 33 parts (0 on the bottom side), 33 nets.

## KiCad design PCB-Kicad/Modul_Lcd_Butoane/Modul_Lcd_Butoane.kicad_pcb

Board: 2 copper layers, 150.0 x 144.0 mm, 34 parts (0 on the bottom side), 9 nets.

Parts:
H1, H2, H3, H4, H5, H6, H11, H12, H13, H14, H15, H16: MountingHole; MountingHole_3.2mm_M3
IC1, IC11: AMS1117 +3.3v; SOT229P700X180-4N
J1, J11: LcdModule; IDC-Header_2x04_P2.54mm_Vertical
J2, J12: LCD_I2C; PinSocket_1x04_P2.54mm_Horizontal
R1, R2, R3, R4, R11, R12, R13, R14: 1k; R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal
SW1, SW11: SW_Left; SW_PUSH-12mm
SW2, SW12: SW_Right; SW_PUSH-12mm
SW3, SW13: SW_Increment; SW_PUSH-12mm
SW4, SW14: SW_Decrement; SW_PUSH-12mm

Connections:
+3.3Vout: IC1.2 (VOUT_1), IC11.2 (VOUT_1), SW1.1, SW2.1, SW3.1, SW4.1, SW11.1, SW12.1, SW13.1, SW14.1
+5V: IC1.3 (VIN), IC11.3 (VIN), J1.7, J2.3, J11.7, J12.3
DECREMENT: J1.4, J11.4, R4.1, R14.1, SW4.2, SW14.2
GND: IC1.1 (GROUND/ADJUST), IC11.1 (GROUND/ADJUST), J1.8, J2.4, J11.8, J12.4, R1.1, R2.1, R3.2, R4.2, R11.1, R12.1, R13.2, R14.2
INCREMENT: J1.3, J11.3, R3.1, R13.1, SW3.2, SW13.2
LEFT: J1.1, J11.1, R1.2, R11.2, SW1.2, SW11.2
RIGHT: J1.2, J11.2, R2.2, R12.2, SW2.2, SW12.2
SCL: J1.5, J2.1, J11.5, J12.1
SDA: J1.6, J2.2, J11.6, J12.2

## Commit log (part)

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2024-04-10 tested with new configuration
2024-04-11 images
2024-04-11 11.04.2024 evening updates, works fine.
2024-04-12 Suporturi pentru senzori + al treilea senzor.
2024-04-14 New Realease
2024-04-14 fixed emergecy brake start delay
2024-04-14 added calibration menu option with only one black line in view
2024-04-15 bug fixing
2024-04-19 buna
2024-04-21 From race but needs work (TO DO)
2024-04-22 Main is in test.
2024-04-24 kicad main board pcb update
2024-04-25 new pcb update
2024-04-29 started implementation of a 2 pixy camera system
2024-05-11 Pins update
2024-05-12 remote and pcb update
2024-05-12 Update RemoteStartStopTest.cpp
    updates
2024-05-17 working with 130 speed
2024-05-25 Updates+working
2024-06-25 uploaded all unlisted 3D files
2024-06-28 2 engines sync
2024-06-29 controller class for only 1 engine
2024-07-02 updates: powerTrain class
2024-08-18 uodates
2024-08-31 integration for the new car model
2024-08-31 3d printing stl parts update
2024-09-02 added support for new motors
2024-09-03 working version
2024-09-04 solved distance sensor low sampling rate
2024-09-05 ported lcd display to oled display
2024-09-12 added 10hz mode to the distance sensor
2024-09-12 working version with new car
2024-09-12 working version, tested
2024-09-13 nwo calculate car speed by the wheel angle and physics
2024-09-14 added maximum acceleration and deceleraton limits
2024-09-14 8.6seconds
2024-09-15 added component list
2024-09-16 started to build a wheel mold
2024-09-27 added wheel tire mold
2024-09-28 added distance sensor calibration
2024-09-28 updated wheel tire mold
2024-11-10 added wheel rim 3d model
2024-11-19 rear speed differential bugfixing
2024-11-25 tested on track
2024-12-02 added rear steering only
2025-01-01 added camera y offset
2025-02-08 fixed emergency braking
2025-02-18 started unit test on bird eye algorithm
2025-02-23 added new wheel arm design
2025-03-05 integrating software on the older car
2025-04-09 working version tested
2025-04-14 Buchares Regional Competition
2025-04-15 started to integrate the mpu9250
2025-04-17 integrated oversteer mitigation
2025-04-25 9.44 seconds
2025-04-27 added EDF
2025-05-01 last update for drone blade
2025-05-03 fixed hard left turn in intersection
2025-05-03 updates 7.3 seconds
2025-05-08 CAR2 8.8 seconds
2025-05-14 NXP 2025 Eindhoven
